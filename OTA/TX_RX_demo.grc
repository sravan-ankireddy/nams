options:
  parameters:
    author: Sravan Ankireddy
    generate_options: qt_gui
    id: RX_test
    output_language: python
    title: USRP test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sa53869/work/nams/OTA/RX_gnu.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sa53869/work/nams/OTA/TX.bin
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Rx Freq domain"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Tx Freq domain"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx time domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx time domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*samp_rate
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 2*samp_rate
    center_freq0: freq
    dev_addr: '"addr=192.168.20.2"'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-432-gd5478261
